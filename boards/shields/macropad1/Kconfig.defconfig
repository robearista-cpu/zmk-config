## boards/shields/macropad1/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD1

config ZMK_KEYBOARD_NAME
    default "macropad1"

endif # SHIELD_MACROPAD1
```
